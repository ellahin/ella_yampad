## boards/shields/yampad/Kconfig.shield
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_YAPMAD
    def_bool $(shields_list_contains,yampad)
```
